//============================================================================
// BmpImg.h — image RGB 24 bits + mini fonte 5x7 + writer BMP, zéro dépendance.
// Utilisé par spectro_png.cpp (CImg se comportait bizarrement sur le rendu pixel).
//============================================================================
#ifndef BMPIMG_H_
#define BMPIMG_H_

#include <vector>
#include <string>
#include <cstdint>
#include <cstdio>
#include <cstring>

struct BmpImg {
    int W, H;
    std::vector<uint8_t> px;  // RGB, ligne par ligne, haut -> bas
    BmpImg(int w, int h, uint8_t r = 255, uint8_t g = 255, uint8_t b = 255)
        : W(w), H(h), px((size_t)w * h * 3) {
        for (size_t i = 0; i + 2 < px.size(); i += 3) { px[i] = r; px[i+1] = g; px[i+2] = b; }
    }
    void set(int x, int y, uint8_t r, uint8_t g, uint8_t b) {
        if (x < 0 || x >= W || y < 0 || y >= H) return;
        size_t i = ((size_t)y * W + x) * 3;
        px[i] = r; px[i+1] = g; px[i+2] = b;
    }
    void rect(int x0, int y0, int x1, int y1, uint8_t r, uint8_t g, uint8_t b, bool fill = false) {
        for (int y = y0; y <= y1; y++) for (int x = x0; x <= x1; x++) {
            if (fill || x == x0 || x == x1 || y == y0 || y == y1) set(x, y, r, g, b);
        }
    }
    void line(int x0, int y0, int x1, int y1, uint8_t r, uint8_t g, uint8_t b) {
        int dx = abs(x1 - x0), dy = -abs(y1 - y0), sx = x0 < x1 ? 1 : -1, sy = y0 < y1 ? 1 : -1, e = dx + dy;
        for (;;) { set(x0, y0, r, g, b); if (x0 == x1 && y0 == y1) break; int e2 = 2*e; if (e2 >= dy) { e += dy; x0 += sx; } if (e2 <= dx) { e += dx; y0 += sy; } }
    }
    void circle(int cx, int cy, int rad, uint8_t r, uint8_t g, uint8_t b) {
        for (int y = -rad; y <= rad; y++) for (int x = -rad; x <= rad; x++)
            if (x*x + y*y <= rad*rad) set(cx + x, cy + y, r, g, b);
    }
    // mini fonte 5x7 (chiffres, lettres maj, quelques signes)
    static const uint8_t* glyph(char c) {
        static const uint8_t G[96][7] = {
        //  ' ' 0x20
        {0,0,0,0,0,0,0},
        // chiffres 0-9 0x30..0x39
        {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E},{0x04,0x0C,0x04,0x04,0x04,0x04,0x0E},{0x0E,0x11,0x01,0x06,0x08,0x10,0x1F},{0x1F,0x02,0x04,0x02,0x01,0x11,0x0E},{0x02,0x06,0x0A,0x12,0x1F,0x02,0x02},{0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E},{0x06,0x08,0x10,0x1E,0x11,0x11,0x0E},{0x1F,0x01,0x02,0x04,0x08,0x08,0x08},{0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},{0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C},
        // : ; < = > ?  0x3A..
        {0,0,0x0C,0x0C,0,0x0C,0},{0,0,0x0C,0x0C,0,0,0},{0x02,0x04,0x08,0x10,0x08,0x04,0x02},{0,0,0x1F,0,0x1F,0,0},{0x08,0x04,0x02,0x01,0x02,0x04,0x08},{0x1F,0x08,0x04,0x02,0x04,0x08,0x1F},{0x1F,0x02,0x04,0x08,0x04,0x02,0x1F},
        // A-Z 0x41..
        {0x0E,0x11,0x11,0x1F,0x11,0x11,0x11},{0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E},{0x0E,0x11,0x10,0x10,0x10,0x11,0x0E},{0x1C,0x11,0x11,0x11,0x11,0x11,0x1C},{0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F},{0x1F,0x10,0x10,0x1E,0x10,0x10,0x10},{0x0E,0x11,0x10,0x17,0x11,0x11,0x0F},{0x11,0x11,0x11,0x1F,0x11,0x11,0x11},{0x0E,0x04,0x04,0x04,0x04,0x04,0x0E},{0x03,0x01,0x01,0x01,0x01,0x11,0x0E},{0x11,0x12,0x14,0x18,0x14,0x12,0x11},{0x10,0x10,0x10,0x10,0x10,0x10,0x1F},{0x11,0x1B,0x15,0x11,0x11,0x11,0x11},{0x11,0x19,0x15,0x13,0x11,0x11,0x11},{0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},{0x1E,0x11,0x11,0x1E,0x10,0x10,0x10},{0x0E,0x11,0x10,0x10,0x10,0x11,0x0E},{0x1F,0x04,0x04,0x04,0x04,0x04,0x04},{0x11,0x11,0x11,0x11,0x11,0x11,0x0E},{0x11,0x11,0x11,0x0A,0x0A,0x04,0x04},{0x11,0x11,0x15,0x15,0x15,0x1B,0x11},{0x11,0x11,0x0A,0x04,0x0A,0x11,0x11},{0x11,0x11,0x0A,0x04,0x04,0x04,0x04},{0x1F,0x01,0x02,0x04,0x08,0x10,0x1F},
        // reste en vide
        };
        int i = (c >= 32 && c < 127) ? (c - 32) : 0;
        return G[i];
    }
    void text(int x, int y, const std::string& s, uint8_t r, uint8_t g, uint8_t b) {
        int cx = x;
        for (char c : s) {
            const uint8_t* gl = glyph(c);
            for (int gy = 0; gy < 7; gy++) for (int gx = 0; gx < 5; gx++)
                if (gl[gy] & (1 << (4 - gx))) set(cx + gx, y + gy, r, g, b);
            cx += 6;
        }
    }
    bool save_bmp(const std::string& path) {
        FILE* f = fopen(path.c_str(), "wb");
        if (!f) return false;
        int rowSize = (W * 3 + 3) & ~3;
        int imgSize = rowSize * H;
        uint8_t hdr[54] = {0};
        hdr[0] = 'B'; hdr[1] = 'M';
        uint32_t fsize = 54 + imgSize;
        uint32_t off = 54, dib = 40;
        memcpy(hdr + 2, &fsize, 4); memcpy(hdr + 10, &off, 4);
        memcpy(hdr + 14, &dib, 4);
        memcpy(hdr + 18, &W, 4); memcpy(hdr + 22, &H, 4);
        uint16_t planes = 1, bpp = 24;
        memcpy(hdr + 26, &planes, 2); memcpy(hdr + 28, &bpp, 2);
        memcpy(hdr + 34, &imgSize, 4);
        fwrite(hdr, 1, 54, f);
        std::vector<uint8_t> row(rowSize, 0);
        for (int y = H - 1; y >= 0; y--) {  // BMP = bas vers haut, BGR
            for (int x = 0; x < W; x++) {
                size_t i = ((size_t)y * W + x) * 3;
                row[x*3] = px[i+2]; row[x*3+1] = px[i+1]; row[x*3+2] = px[i];
            }
            fwrite(row.data(), 1, rowSize, f);
        }
        fclose(f);
        return true;
    }
};

#endif // BMPIMG_H_
